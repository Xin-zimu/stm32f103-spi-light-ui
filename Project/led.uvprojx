# Keil uVision project led.uvprojx, settings and files
target led (5060960::V5.06 update 7 (build 960)::.)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\inc;..\User;..\SYSTEM\delay;..\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c misc.c
  group User
    ../User/: main.c stm32f10x_conf.h bsp_st7789.c bsp_st7789.h fault_handlers.c
  group SYS
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.h
