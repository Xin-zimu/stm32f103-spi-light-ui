#include "ui_font.h"

static const uint8_t UI_FONT_BLANK[5] = {0U, 0U, 0U, 0U, 0U};

/*
 * Return a compact ASCII glyph bitmap for the UI renderer.
 *
 * Glyphs are stored as five 7-bit columns and drawn inside an 8x12 cell by
 * `ui_draw.c`. Keeping the glyph table narrow preserves Flash while isolating
 * all font data behind one interface, so a true 8x12 table can replace it
 * later without changing pages.
 *
 * Parameters:
 * ch: ASCII character. Lowercase letters are mapped to uppercase.
 *
 * Return value:
 * Pointer to five column bytes. Unknown characters map to a blank glyph.
 *
 * Side effects:
 * None.
 */
const uint8_t *UI_FontGetGlyph(char ch)
{
    static const uint8_t digits[10][5] =
    {
        {0x3EU, 0x51U, 0x49U, 0x45U, 0x3EU},
        {0x00U, 0x42U, 0x7FU, 0x40U, 0x00U},
        {0x62U, 0x51U, 0x49U, 0x49U, 0x46U},
        {0x22U, 0x49U, 0x49U, 0x49U, 0x36U},
        {0x18U, 0x14U, 0x12U, 0x7FU, 0x10U},
        {0x2FU, 0x49U, 0x49U, 0x49U, 0x31U},
        {0x3EU, 0x49U, 0x49U, 0x49U, 0x32U},
        {0x01U, 0x71U, 0x09U, 0x05U, 0x03U},
        {0x36U, 0x49U, 0x49U, 0x49U, 0x36U},
        {0x26U, 0x49U, 0x49U, 0x49U, 0x3EU}
    };
    static const uint8_t letters[26][5] =
    {
        {0x7EU, 0x09U, 0x09U, 0x09U, 0x7EU},
        {0x7FU, 0x49U, 0x49U, 0x49U, 0x36U},
        {0x3EU, 0x41U, 0x41U, 0x41U, 0x22U},
        {0x7FU, 0x41U, 0x41U, 0x22U, 0x1CU},
        {0x7FU, 0x49U, 0x49U, 0x49U, 0x41U},
        {0x7FU, 0x09U, 0x09U, 0x09U, 0x01U},
        {0x3EU, 0x41U, 0x49U, 0x49U, 0x7AU},
        {0x7FU, 0x08U, 0x08U, 0x08U, 0x7FU},
        {0x00U, 0x41U, 0x7FU, 0x41U, 0x00U},
        {0x20U, 0x40U, 0x41U, 0x3FU, 0x01U},
        {0x7FU, 0x08U, 0x14U, 0x22U, 0x41U},
        {0x7FU, 0x40U, 0x40U, 0x40U, 0x40U},
        {0x7FU, 0x02U, 0x0CU, 0x02U, 0x7FU},
        {0x7FU, 0x04U, 0x08U, 0x10U, 0x7FU},
        {0x3EU, 0x41U, 0x41U, 0x41U, 0x3EU},
        {0x7FU, 0x09U, 0x09U, 0x09U, 0x06U},
        {0x3EU, 0x41U, 0x51U, 0x21U, 0x5EU},
        {0x7FU, 0x09U, 0x19U, 0x29U, 0x46U},
        {0x46U, 0x49U, 0x49U, 0x49U, 0x31U},
        {0x01U, 0x01U, 0x7FU, 0x01U, 0x01U},
        {0x3FU, 0x40U, 0x40U, 0x40U, 0x3FU},
        {0x1FU, 0x20U, 0x40U, 0x20U, 0x1FU},
        {0x7FU, 0x20U, 0x18U, 0x20U, 0x7FU},
        {0x63U, 0x14U, 0x08U, 0x14U, 0x63U},
        {0x07U, 0x08U, 0x70U, 0x08U, 0x07U},
        {0x61U, 0x51U, 0x49U, 0x45U, 0x43U}
    };
    static const uint8_t glyph_dash[5] = {0x08U, 0x08U, 0x08U, 0x08U, 0x08U};
    static const uint8_t glyph_colon[5] = {0x00U, 0x00U, 0x14U, 0x00U, 0x00U};
    static const uint8_t glyph_slash[5] = {0x20U, 0x10U, 0x08U, 0x04U, 0x02U};
    static const uint8_t glyph_dot[5] = {0x00U, 0x40U, 0x60U, 0x00U, 0x00U};
    static const uint8_t glyph_percent[5] = {0x23U, 0x13U, 0x08U, 0x64U, 0x62U};

    if ((ch >= '0') && (ch <= '9'))
    {
        return digits[ch - '0'];
    }
    if ((ch >= 'a') && (ch <= 'z'))
    {
        ch = (char)(ch - 'a' + 'A');
    }
    if ((ch >= 'A') && (ch <= 'Z'))
    {
        return letters[ch - 'A'];
    }
    if (ch == '-')
    {
        return glyph_dash;
    }
    if (ch == ':')
    {
        return glyph_colon;
    }
    if (ch == '/')
    {
        return glyph_slash;
    }
    if (ch == '.')
    {
        return glyph_dot;
    }
    if (ch == '%')
    {
        return glyph_percent;
    }

    return UI_FONT_BLANK;
}
